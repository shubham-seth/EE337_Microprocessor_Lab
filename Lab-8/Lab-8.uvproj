# Keil uVision project Lab-8.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C5131A Microchip
  cpu: IRAM(0-0xFF) XRAM(0-0x3FF) IROM(0-0x7FFF) CLOCK(32000000) MODP2
  output: Lab-8 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./lab8-s2/spi_adc_lab8/: main.c
